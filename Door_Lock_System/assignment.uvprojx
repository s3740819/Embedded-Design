# Keil uVision project assignment.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: assignment
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\Library\CMSIS\Include;..\Library\NUC1xx-LB_002\Include;..\Library\NUC100Series\Include;..\Library\NuMakerLib\Include;..\Library\StdDriver\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ../Library/NUC100Series/Source/: system_NUC100Series.c
    ../Library/NUC100Series/Source/ARM/: startup_NUC100Series.s
    ./: main.c
    ../Library/NUC1xx-LB_002/Source/: LCD.c
    ../Library/NuMakerLib/Source/: SYS_init.c
    ../Library/StdDriver/Source/: clk.c gpio.c spi.c
  group Header
    ./: door_lock_system.h
